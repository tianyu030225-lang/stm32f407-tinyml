# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1,HSE_VALUE=8000000,AI_ADAPTER_ENABLE_NANOEDGE=1
  c include: ..\CORE;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\App;..\AI;..\AI\vendor;..\BSP;..\Components
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h stm32f4xx_conf.h
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_i2c.c
  group APP
    ../App/: app_types.c app_mode.c app_state.c app_runtime.c app_time.c imu_task.c command_task.c ai_task.c app_tx.c
  group AI
    ../AI/: ai_adapter.c
    ../AI/vendor/: ai_vendor_port.c libneai.a
  group BSP
    ../BSP/: bsp_i2c.c bsp_mpu6050.c bsp_usart.c bsp_led.c bsp_buzzer.c
  group COMPONENTS
    ../Components/: ring_buffer.c command_parser.c window_pool.c
  group FreeRTOS_CORE
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSI_PORT
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
